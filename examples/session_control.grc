options:
  parameters:
    author: LogicRF Technologies
    category: '[LogicRF]'
    description: H102 Session and Control, construction only offline acceptance; no automatic RF
    generate_options: no_gui
    id: session_control_grc
    output_language: python
    run_options: run
  states: {}

blocks:
- name: h102_device_0
  id: logicrf_h102_iio_session
  parameters:
    backend: iio
    uri: ip:HOST
    rx_channels: (1,)
    tx_channels: ()
    profile: 4msps-2mhz-common
    sample_rate: '4000000'
    rx_frequency: '1000000000'
    tx_frequency: '1000000000'
    rx_gain_db: '{1: 20}'
    rf_enabled: 'False'
    attenuation_db: '40'
    sample_limit: '0'
    tx_samples: '0'
    usb_seconds: '0'
  states: {}
- name: rx1
  id: logicrf_h102_rx_source
  parameters:
    board: h102_device_0
    channel: '1'
  states: {}
- name: sink1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: control
  id: logicrf_h102_control
  parameters:
    device: h102_device_0
  states: {}

connections:
- [rx1, '0', sink1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
