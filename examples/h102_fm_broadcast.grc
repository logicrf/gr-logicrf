options:
  parameters:
    author: LogicRF Technologies
    category: '[LogicRF]'
    description: 'Interactive FM: editable DSP, asynchronous owner, RF/audio time domain'
    generate_options: qt_gui
    id: h102_fm_broadcast
    output_language: python
    run_options: run
    title: LogicRF H102 FM · GRC
    run: 'False'
  states: {}

blocks:
- name: h102
  id: logicrf_h102_grc_rx_session
  parameters:
    backend: iio
    host: DEVICE_IP
    channels: (rx_channel,)
    profile: radio_profile['profile']
    sample_rate: radio_profile['rate_hz']
    frequency: '98100000'
    gain_db: '20'
    fm: 'True'
  states: {}
- name: rx1
  id: logicrf_h102_rx_source
  parameters:
    board: h102
    channel: rx_channel
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: H102 RX
    fftsize: '4096'
    fc: '98100000'
    bw: radio_profile['rate_hz']
    wintype: window.WIN_HANN
    update_time: '0.1'
    ymax: '5'
    gui_hint: analysis@0:0,0
    ctrlpanel: 'True'
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    type: complex
    name: Selected RX Waterfall
    fftsize: '1024'
    fc: '98100000'
    bw: radio_profile['rate_hz']
    wintype: window.WIN_HANN
    update_time: '0.1'
    gui_hint: analysis@0:1,0
  states: {}
- name: channel_filter
  id: low_pass_filter
  parameters:
    type: fir_filter_ccf
    decim: '8'
    gain: '1'
    samp_rate: radio_profile['rate_hz']
    cutoff_freq: '90000'
    width: '6000'
    win: window.WIN_HAMMING
  states: {}
- name: fm
  id: analog_fm_demod_cf
  parameters:
    chan_rate: '192000'
    audio_decim: '4'
    deviation: '75000'
    audio_pass: '15000'
    audio_stop: '18000'
    gain: '1'
    tau: '50e-6'
  states: {}
- name: volume
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: audio_volume
  states: {}
- name: speaker
  id: logicrf_fm_audio_sink
  parameters:
    latency_ms: '1000'
  states: {}
- name: observer1
  id: logicrf_h102_observer
  parameters: {}
  states: {}
- name: rx_panel
  id: logicrf_h102_rx_panel
  parameters:
    board: h102
    observers: '{rx_channel: ''observer1''}'
    displays: '[''spectrum'', ''waterfall'']'
    audio: speaker
    fm: 'True'
    gui_hint: 0,0,1,2
  states: {}
- name: analysis
  id: qtgui_tab_widget
  parameters:
    num_tabs: '3'
    label0: RF spectrum
    label1: IQ time
    label2: Audio time
    gui_hint: 1,0,1,2
  states: {}
- name: iq_time
  id: qtgui_time_sink_x
  parameters:
    type: complex
    name: Selected RX I/Q — relative time
    size: '4096'
    srate: radio_profile['rate_hz']
    ctrlpanel: 'True'
    gui_hint: analysis@1:0,0
  states: {}
- name: audio_time
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: FM audio — relative time
    size: '4800'
    srate: '48000'
    ctrlpanel: 'True'
    gui_hint: analysis@2:0,0
  states: {}
- name: audio_volume
  id: variable_qtgui_range
  parameters:
    label: Volume / mute=0
    value: '0.4'
    start: '0'
    stop: '1'
    step: '0.01'
    gui_hint: 2,0,1,2
  states: {}
- name: magnitude_rx1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: magnitude_time
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: IQ magnitude — relative time
    size: '4096'
    srate: radio_profile['rate_hz']
    ctrlpanel: 'True'
    ymin: '0'
    ymax: '1.5'
    gui_hint: analysis@1:1,0
  states: {}
- name: radio_profile
  id: variable_logicrf_h102_profile
  parameters:
    preset: 1p536msps-0p5mhz
  states: {}
- name: rx_channel
  id: variable_logicrf_h102_rx_channel
  parameters:
    channel: '1'
  states: {}

connections:
- [rx1, '0', spectrum, '0']
- [rx1, '0', waterfall, '0']
- [rx1, '0', channel_filter, '0']
- [channel_filter, '0', fm, '0']
- [fm, '0', volume, '0']
- [volume, '0', speaker, '0']
- [rx1, '0', observer1, '0']
- [rx1, '0', iq_time, '0']
- [volume, '0', audio_time, '0']
- [rx1, '0', magnitude_rx1, '0']
- [magnitude_rx1, '0', magnitude_time, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
