options:
  parameters:
    author: LogicRF Technologies
    category: '[LogicRF]'
    description: Finite USB TX digital RAMP32 candidate, RF OFF, IP-only device control
    generate_options: no_gui
    id: usb_dual_tx_digital_grc
    output_language: python
    run_options: run
  states: {}

blocks:
- name: h102_device_0
  id: logicrf_h102_device
  parameters:
    backend: usb
    direction: tx
    pattern: ramp32
    uri: ip:DEVICE_IP
    profile: 40msps-20mhz
    tx_samples: '400015360'
    usb_seconds: '10'
    sample_rate: '40000000'
    center_frequency: '2450000000'
  states: {}
- name: ramp1
  id: logicrf_h102_tx_ramp_source
  parameters:
    board: h102_device_0
    channel: '1'
  states: {}
- name: ramp2
  id: logicrf_h102_tx_ramp_source
  parameters:
    board: h102_device_0
    channel: '2'
  states: {}
- name: sink1
  id: logicrf_h102_tx_sink
  parameters:
    board: h102_device_0
    channel: '1'
  states: {}
- name: sink2
  id: logicrf_h102_tx_sink
  parameters:
    board: h102_device_0
    channel: '2'
  states: {}

connections:
- [ramp1, '0', sink1, '0']
- [ramp2, '0', sink2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
