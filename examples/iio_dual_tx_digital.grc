options:
  parameters:
    author: LogicRF Technologies
    category: '[LogicRF]'
    description: Finite IIO digital submission only, RF OFF; not SSI or RF validation
    generate_options: no_gui
    id: iio_dual_tx_digital_grc
    output_language: python
    run_options: run
  states: {}

blocks:
- name: h102_device_0
  id: logicrf_h102_device
  parameters:
    backend: iio
    uri: ip:192.0.2.10
    configuration: 8msps-4mhz-common
    direction: tx
    tx_samples: '80000000'
    sample_rate: '8000000'
    center_frequency: '2400000000'
  states: {}
- name: source1
  id: blocks_vector_source_x
  parameters:
    type: complex
    vector: (0.25-0.5j,)
    repeat: 'True'
  states: {}
- name: source2
  id: blocks_vector_source_x
  parameters:
    type: complex
    vector: (-0.125+0.375j,)
    repeat: 'True'
  states: {}
- name: sink1
  id: logicrf_h102_tx_sink
  parameters:
    board: h102_device_0
    channel: '1'
  states: {}
- name: sink2
  id: logicrf_h102_tx_sink
  parameters:
    board: h102_device_0
    channel: '2'
  states: {}

connections:
- [source1, '0', sink1, '0']
- [source2, '0', sink2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
