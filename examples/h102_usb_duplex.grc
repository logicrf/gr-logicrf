options:
  parameters:
    author: LogicRF Technologies
    category: '[LogicRF]'
    description: h102_usb_duplex RF OFF by default; one shared owner
    generate_options: qt_gui
    id: h102_usb_duplex
    output_language: python
    run_options: run
    title: h102_usb_duplex RF OFF by default; one shared owner
  states: {}

blocks:
- name: h102
  id: logicrf_h102_iio_session
  parameters:
    backend: usb
    host: DEVICE_IP
    uri: ''
    rx_channels: (1,)
    tx_channels: (1,)
    profile: 40msps-20mhz-common
    sample_rate: '40000000'
    rx_frequency: '1000000000'
    tx_frequency: '1000000000'
    rx_gain_db: '{1: 20}'
    rf_enabled: 'False'
    attenuation_db: '40'
    sample_limit: '0'
    tx_samples: '0'
    usb_seconds: '0'
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    type: complex
    samp_rate: '40000000'
    waveform: analog.GR_COS_WAVE
    freq: '250000'
    amp: '0.25'
    offset: '0'
    phase: '0'
  states: {}
- name: tx1
  id: logicrf_h102_tx_sink
  parameters:
    board: h102
    channel: '1'
  states: {}
- name: rx1
  id: logicrf_h102_rx_source
  parameters:
    board: h102
    channel: '1'
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: H102 RX
    fftsize: '4096'
    fc: '1000000000'
    bw: '40000000'
    wintype: window.WIN_HANN
    update_time: '0.1'
    ymax: '5'
  states: {}

connections:
- [tone, '0', tx1, '0']
- [rx1, '0', spectrum, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
