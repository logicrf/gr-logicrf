options:
  parameters:
    author: LogicRF Technologies
    category: '[LogicRF]'
    description: P0 mock only, no hardware or RF
    generate_options: no_gui
    id: mock_dual_rx_grc
    output_language: python
    run_options: run
  states: {}

blocks:
- name: h102_device_0
  id: logicrf_h102_device
  parameters:
    backend: mock
    sample_rate: '100000'
    center_frequency: '150000000'
    mock_samples: '12345'
  states: {}
- name: rx1
  id: logicrf_h102_rx_source
  parameters:
    board: h102_device_0
    channel: '1'
  states: {}
- name: rx2
  id: logicrf_h102_rx_source
  parameters:
    board: h102_device_0
    channel: '2'
  states: {}
- name: sink1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: sink2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}

connections:
- [rx1, '0', sink1, '0']
- [rx2, '0', sink2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
