options:
  parameters:
    author: LogicRF Technologies
    category: '[LogicRF]'
    description: h102_usb_spectrum IP only; RX only
    generate_options: qt_gui
    id: h102_usb_spectrum
    output_language: python
    run_options: run
    title: h102_usb_spectrum IP only; RX only
  states: {}

blocks:
- name: h102
  id: logicrf_h102_iio_session
  parameters:
    backend: usb
    host: DEVICE_IP
    uri: ''
    rx_channels: (1,2)
    tx_channels: ()
    profile: 40msps-20mhz-common
    sample_rate: '40000000'
    rx_frequency: '1000000000'
    tx_frequency: '1000000000'
    rx_gain_db: '{1: 20, 2: 20}'
    rf_enabled: 'False'
    attenuation_db: '40'
    sample_limit: '0'
    tx_samples: '0'
    usb_seconds: '0'
  states: {}
- name: rx1
  id: logicrf_h102_rx_source
  parameters:
    board: h102
    channel: '1'
  states: {}
- name: rx2
  id: logicrf_h102_rx_source
  parameters:
    board: h102
    channel: '2'
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: H102 RX
    fftsize: '4096'
    fc: '1000000000'
    bw: '40000000'
    nconnections: '2'
    wintype: window.WIN_HANN
    update_time: '0.1'
    ymax: '5'
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    type: complex
    name: RX1 Waterfall
    fftsize: '1024'
    fc: '1000000000'
    bw: '40000000'
    wintype: window.WIN_HANN
    update_time: '0.1'
  states: {}

connections:
- [rx1, '0', spectrum, '0']
- [rx2, '0', spectrum, '1']
- [rx1, '0', waterfall, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
